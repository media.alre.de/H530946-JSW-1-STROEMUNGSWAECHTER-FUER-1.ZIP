Properties of the parts of a building model (IFC4)

# File
Description: Strömungswächter für 1", ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: H530946, Strömungswächter für 1"
In: Raum
Description: Zur Überwachung kleiner und mittlerer, nicht aggressiver Flüssigkeitsmengen in Rohrleitungen mit Durchmesser von 1". Das Gerät benötigt keine Versorgungsspannung. Einbau: Senkrecht in eine waagerechte Rohrleitung. Beruhigungsstrecke mindestens 5-facher Rohrdurchmesser vor und hinter dem Paddel. Die Montage/Befestigung erfolgt mittels Überwurfmutter G 3/8" auf Anlötstutzen (zum Einlöten in ein Norm-Kupfer-T-Stück mit Abgang 1/2") oder T-Stück. Nicht trinkwassergeprüft. Schaltpunkt fallend 13,5 … 16,5 l/min, Schaltpunkt steigend 17,0 … 20,5 l/min, Schaltdifferenz 3,5 l/min. Genauigkeit ±15 % vom eingestellten Sollwert (Schaltwerte gelten nur bei Einbau des Strömungswächters in unser T-Stück. Bei Verwendung von Kupfer-T-Stücken erhöhen sich die Schaltwerte).; Classification: EC011194 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: H530946; ModelLabel: JSW-1; GlobalTradeItemNumber: 4050528044792; ProductURL: https://alre.de/produkt_H530946
Pset_Specification - NominalLength: 0.102 m; NominalWidth: 0.0725 m; NominalDepth: 0.03 m; NetWeight: 0.239
Pset_ALRE_ETIM_Properties - Spannungsart: AC; Explosionsgeschützt: no; Schutzart (IP): IP65; Ausführung Aufnehmer/Fühler: Fahne; Max. Spannung der Kontakte: 230; Werkstoff des Prozessanschlusses: Messing; Geeignet für Medium: Flüssigstoffe; Material Wimpel: rostfreier Stahl; Max. Kontaktbelastung: 5; ETIM-Klasse: EC011194; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-H530946.pdf
